# Keil uVision project DogUs.uvprojx, settings and files
target LoRaS5 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  output: SX1272PingPong
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_STM32F0 --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DDEVICE_SERIAL_FC=1 -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DTARGET_STM32F091RC -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M0 -DTARGET_NUCLEO_F091RC -D__CORTEX_M0 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DMBED_BUILD_TIMESTAMP=1486362247.98 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM -DTARGET_LIKE_MBED
  c include: .; SX1272Lib; SX1272Lib/debug; SX1272Lib/enums; SX1272Lib/radio; SX1272Lib/registers; SX1272Lib/sx1272; SX1272Lib/typedefs; mbed/.; mbed/TARGET_NUCLEO_F091RC; mbed/TARGET_NUCLEO_F091RC/TARGET_STM; mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0; mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F091RC; mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F091RC/device; mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/device; mbed/TARGET_NUCLEO_F091RC/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_F091RC/TOOLCHAIN_ARM_STD/stm32f091rc.sct
  group 
    ./: mbed_config.h main.h main.cpp
  group hal
    mbed/hal/: Driver_Common.h Driver_Storage.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
  group sx1272
    SX1272Lib/sx1272/: sx1272-hal.h sx1272.h sx1272-hal.cpp sx1272.cpp
  group platform
    mbed/platform/: CThunk.h CallChain.h Callback.h CircularBuffer.h FunctionPointer.h PlatformMutex.h SingletonPtr.h Transaction.h critical.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_stats.h platform.h rtc_time.h semihost_api.h toolchain.h wait_api.h
  group drivers
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
  group registers
    SX1272Lib/registers/: sx1272Regs-Fsk.h sx1272Regs-LoRa.h
  group device
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F091RC/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f091xc.h stm32f0xx.h system_stm32f0xx.h
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/device/: stm32f0xx_hal_smartcard.h stm32_hal_legacy.h stm32f0xx_hal.h stm32f0xx_hal_adc.h stm32f0xx_hal_adc_ex.h stm32f0xx_hal_can.h stm32f0xx_hal_cec.h stm32f0xx_hal_comp.h stm32f0xx_hal_conf.h stm32f0xx_hal_cortex.h stm32f0xx_hal_crc.h stm32f0xx_hal_crc_ex.h stm32f0xx_hal_dac.h stm32f0xx_hal_dac_ex.h stm32f0xx_hal_def.h stm32f0xx_hal_dma.h stm32f0xx_hal_dma_ex.h stm32f0xx_hal_flash.h stm32f0xx_hal_flash_ex.h stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_i2s.h stm32f0xx_hal_irda.h stm32f0xx_hal_irda_ex.h stm32f0xx_hal_iwdg.h stm32f0xx_hal_pcd.h stm32f0xx_hal_pcd_ex.h stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc_ex.h stm32f0xx_hal_rtc.h stm32f0xx_hal_rtc_ex.h stm32f0xx_hal_smartcard_ex.h stm32f0xx_hal_smbus.h stm32f0xx_hal_spi.h stm32f0xx_hal_spi_ex.h stm32f0xx_hal_tim.h stm32f0xx_hal_tim_ex.h stm32f0xx_hal_tsc.h stm32f0xx_hal_uart.h stm32f0xx_hal_uart_ex.h stm32f0xx_hal_usart.h stm32f0xx_hal_usart_ex.h stm32f0xx_hal_wwdg.h stm32f0xx_ll_adc.h stm32f0xx_ll_bus.h stm32f0xx_ll_comp.h stm32f0xx_ll_cortex.h stm32f0xx_ll_crc.h stm32f0xx_ll_crs.h stm32f0xx_ll_dac.h stm32f0xx_ll_dma.h stm32f0xx_ll_exti.h stm32f0xx_ll_gpio.h stm32f0xx_ll_i2c.h stm32f0xx_ll_iwdg.h stm32f0xx_ll_pwr.h stm32f0xx_ll_rcc.h stm32f0xx_ll_rtc.h stm32f0xx_ll_spi.h stm32f0xx_ll_system.h stm32f0xx_ll_tim.h stm32f0xx_ll_usart.h stm32f0xx_ll_utils.h stm32f0xx_ll_wwdg.h
  group TARGET_STM
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/: mbed_rtx.h rtc_api_hal.h
  group TARGET_STM32F0
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/: PeripheralPins.h common_objects.h device.h gpio_object.h i2c_device.h
  group radio
    SX1272Lib/radio/: radio.h radio.cpp
  group TARGET_NUCLEO_F091RC
    mbed/TARGET_NUCLEO_F091RC/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/TARGET_NUCLEO_F091RC/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F091RC/: PeripheralNames.h PinNames.h PortNames.h objects.h
  group debug
    SX1272Lib/debug/: debug.h
  group typedefs
    SX1272Lib/typedefs/: typedefs.h
  group enums
    SX1272Lib/enums/: enums.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_NUCLEO_F091RC/TOOLCHAIN_ARM_STD/: stm32f0xx_hal_smartcard.o PeripheralPins.o analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed_board.o mbed_overrides.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32f091rc.o stm32f0xx_hal.o stm32f0xx_hal_adc.o stm32f0xx_hal_adc_ex.o stm32f0xx_hal_can.o stm32f0xx_hal_cec.o stm32f0xx_hal_comp.o stm32f0xx_hal_cortex.o stm32f0xx_hal_crc.o stm32f0xx_hal_crc_ex.o stm32f0xx_hal_dac.o stm32f0xx_hal_dac_ex.o stm32f0xx_hal_dma.o stm32f0xx_hal_flash.o stm32f0xx_hal_flash_ex.o stm32f0xx_hal_gpio.o stm32f0xx_hal_i2c.o stm32f0xx_hal_i2c_ex.o stm32f0xx_hal_i2s.o stm32f0xx_hal_irda.o stm32f0xx_hal_iwdg.o stm32f0xx_hal_pcd.o stm32f0xx_hal_pcd_ex.o stm32f0xx_hal_pwr.o stm32f0xx_hal_pwr_ex.o stm32f0xx_hal_rcc.o stm32f0xx_hal_rcc_ex.o stm32f0xx_hal_rtc.o stm32f0xx_hal_rtc_ex.o stm32f0xx_hal_smartcard_ex.o stm32f0xx_hal_smbus.o stm32f0xx_hal_spi.o stm32f0xx_hal_spi_ex.o stm32f0xx_hal_tim.o stm32f0xx_hal_tim_ex.o stm32f0xx_hal_tsc.o stm32f0xx_hal_uart.o stm32f0xx_hal_uart_ex.o stm32f0xx_hal_usart.o stm32f0xx_hal_wwdg.o stm32f0xx_ll_adc.o stm32f0xx_ll_comp.o stm32f0xx_ll_crc.o stm32f0xx_ll_crs.o stm32f0xx_ll_dac.o stm32f0xx_ll_dma.o stm32f0xx_ll_exti.o stm32f0xx_ll_gpio.o stm32f0xx_ll_i2c.o stm32f0xx_ll_pwr.o stm32f0xx_ll_rcc.o stm32f0xx_ll_rtc.o stm32f0xx_ll_spi.o stm32f0xx_ll_tim.o stm32f0xx_ll_usart.o stm32f0xx_ll_utils.o stm_spi_api.o sys.o system_stm32f0xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o mbed.ar
  group mbed
    mbed/: mbed.h
